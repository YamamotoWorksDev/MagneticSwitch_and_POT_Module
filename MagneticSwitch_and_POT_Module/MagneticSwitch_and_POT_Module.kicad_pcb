# Repository YamamotoWorksDev/MagneticSwitch_and_POT_Module

File README.md:

# MagneticSwitch & POT Module
This module is a convenient prototyping board for building user interfaces for audio devices such as MIDI controllers, synthesizers, and mixers. It features 10 magnetic switches, 12 potentiometers (POTs), and 10 RGB LEDs.

## How to buy
- [Tindie(International)](https://www.tindie.com/products/yamamotoworks/magneticsw-and-pot-module/)  
- [BASE(Japan)](https://miyworks.base.shop/items/139586742)

## Specifications
- VCC: 3.3-5V
- Analog Mux: [Onsemi MC74HC4067A](https://www.onsemi.com/products/timing-logic-memory/standard-logic/multiplexers/mc74hc4067a)
- POT: [Alps RK09K1130A5R(10k)](https://tech.alpsalpine.com/e/products/detail/RK09K1130A5R/) x12
- Hall Effect Sensor: [TI DRV5056A8QDBZR](https://www.ti.com/product/ja-jp/DRV5056/part-details/DRV5056A3QDBZR) x10
- RGB LED: [Würth Elektronik WL-ICLED 1312020030000](https://www.we-online.com/en/components/products/WL-ICLED?sq=1312020030000#1312020030000) x10

## Supported magnetic switches
- [Gateron Low Profile Magnetic Jade Pro HE](https://www.gateron.com/products/gateron-full-pom-low-profile-magnetic-jade-pro-switch-set?VariantsId=10870)
- [Gateron Low Profile Magnetic Jade HE](https://www.gateron.com/products/gateron-low-profile-magnetic-jade-switch?VariantsId=10872)

## Features
- Six magnetic switches (KEY0–5) can be connected directly to your microcontroller’s ADC pins.
- The twelve POTs (RV1–12) and four magnetic switches (SUB_KEY6–9) are routed through an **MC74HC4067ADWR2G** analog multiplexer. By driving **S0–S3**, you can select one of 16 channels and read its analog value from **AIN**.
  - The channel mapping is shown below:
  
    | S0 | S1 | S2 | S3 | AIN source |
    |----|----|----|----|------------|
    | L  | L  | L  | L  | RV1        |
    | H  | L  | L  | L  | RV2        |
    | L  | H  | L  | L  | RV3        |
    | H  | H  | L  | L  | RV4        |
    | L  | L  | H  | L  | RV5        |
    | H  | L  | H  | L  | RV6        |
    | L  | H  | H  | L  | RV7        |
    | H  | H  | H  | L  | RV8        |
    | L  | L  | L  | H  | RV9        |
    | H  | L  | L  | H  | RV10       |
    | L  | H  | L  | H  | RV11       |
    | H  | H  | L  | H  | RV12       |
    | L  | L  | H  | H  | SUB_KEY6   |
    | H  | L  | H  | H  | SUB_KEY7   |
    | L  | H  | H  | H  | SUB_KEY8   |
    | H  | H  | H  | H  | SUB_KEY9   |

- The RGB LEDs (1312020030000) are addressable and use a NeoPixel-compatible (WS2812-style) single-wire control interface.

## Application Example
- [JUMBLEQ](https://github.com/yamamo2shun1/JUMBLEQ)

## Size

## Photo

## License
The hardware design files in this repository are licensed under the
**CERN Open Hardware Licence Version 2 - Permissive (CERN-OHL-P-2.0)**.

Unless otherwise stated, the following are treated as hardware design files covered by CERN-OHL-P-2.0:

- KiCad schematic files
- PCB layout files

A copy of the license text is provided in the `LICENSE` file.

## KiCad design MagneticSwitch_and_POT_Module/MagneticSwitch_and_POT_Module.kicad_pcb

Board: 4 copper layers, 114.3 x 85.0 mm, 77 parts (42 on the bottom side), 39 nets.

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C6, C7, C25, C27, C29, C31: 10nF; C_0402_1005Metric
C8, C9, C10, C11, C12, C13, C24, C26, C28, C30: C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 100nF; C_0402_1005Metric
ICLED1, ICLED2, ICLED3, ICLED4, ICLED5, ICLED6, ICLED7, ICLED8, ICLED9, ICLED10: 1312020030000
J1, J2, J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12: 10k; RK09K1130A5R
U1, U2, U3, U4, U5, U6, U7, U9, U10, U11: DRV5056A3QDBZR; SOT-23
U8: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
/KEY0: C8.1, J2.1, R1.2, U2.2 (OUT)
/KEY1: C9.1, J2.2, R2.2, U3.2 (OUT)
/KEY2: C10.1, J2.3, R3.2, U4.2 (OUT)
/KEY3: C11.1, J2.4, R4.2, U5.2 (OUT)
/KEY4: C12.1, J2.5, R5.2, U6.2 (OUT)
/KEY5: C13.1, J2.6, R6.2, U7.2 (OUT)
/KEY6: C24.1, R7.2, U1.2 (OUT), U8.19 (I12)
/KEY7: C26.1, R8.2, U8.18 (I13), U9.2 (OUT)
/KEY8: C28.1, R9.2, U8.17 (I14), U10.2 (OUT)
/KEY9: C30.1, R10.2, U8.16 (I15), U11.2 (OUT)
/L0: RV1.2, U8.9 (I0)
/L1: RV2.2, U8.8 (I1)
/L2: RV3.2, U8.7 (I2)
/L3: RV4.2, U8.6 (I3)
/L4: RV5.2, U8.5 (I4)
/L5: RV6.2, U8.4 (I5)
/LEDs/DIN: ICLED1.3 (DIN), J3.5
/R0: RV7.2, U8.3 (I6)
/R1: RV8.2, U8.2 (I7)
/R2: RV9.2, U8.23 (I8)
/R3: RV10.2, U8.22 (I9)
/R4: RV11.2, U8.21 (I10)
/R5: RV12.2, U8.20 (I11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, ICLED1.4 (VSS), ICLED2.4 (VSS), ICLED3.4 (VSS), ICLED4.4 (VSS), ICLED5.4 (VSS), ICLED6.4 (VSS), ICLED7.4 (VSS), ICLED8.4 (VSS), ICLED9.4 (VSS), ICLED10.4 (VSS), J3.6, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.12 (GND), U8.15 (~E), U9.3 (GND), U10.3 (GND), U11.3 (GND)
unnamed: ICLED1.1 (DOUT), ICLED2.3 (DIN)
unnamed: ICLED2.1 (DOUT), ICLED3.3 (DIN)
unnamed: ICLED3.1 (DOUT), ICLED4.3 (DIN)
unnamed: ICLED4.1 (DOUT), ICLED5.3 (DIN)
unnamed: ICLED5.1 (DOUT), ICLED6.3 (DIN)
unnamed: ICLED6.1 (DOUT), ICLED7.3 (DIN)
unnamed: ICLED7.1 (DOUT), ICLED8.3 (DIN)
unnamed: ICLED8.1 (DOUT), ICLED9.3 (DIN)
unnamed: ICLED9.1 (DOUT), ICLED10.3 (DIN)
unnamed: J1.2, U8.10 (S0)
unnamed: J1.3, U8.11 (S1)
unnamed: J1.4, U8.14 (S2)
unnamed: J1.5, U8.13 (S3)
unnamed: J1.6, U8.1 (COM)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C27.1, C29.1, C31.1, ICLED1.2 (VDD), ICLED2.2 (VDD), ICLED3.2 (VDD), ICLED4.2 (VDD), ICLED5.2 (VDD), ICLED6.2 (VDD), ICLED7.2 (VDD), ICLED8.2 (VDD), ICLED9.2 (VDD), ICLED10.2 (VDD), J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, U1.1 (VCC), U2.1 (VCC), U3.1 (VCC), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC), U7.1 (VCC), U8.24 (VCC), U9.1 (VCC), U10.1 (VCC), U11.1 (VCC)

## Commit log

2026-03-09 Add CERN-OHL-P-2.0 license
2026-03-09 Update .gitignore to exclude CAD backups and artifacts
    Ignore backup directories, JLCPCB manufacturing files, and STEP models to keep the repository clean of generated and redundant files.
2026-03-09 Add KiCad project files.
2026-03-09 Revise README with project details and licensing
    Updated project title and added specifications, size, and license information to README.
2026-03-09 Add comment.
2026-03-09 Add Rev B schematic PDF
2026-03-09 Revise README structure and add photo section
    Updated section headings and added a photo section.
2026-03-09 Enhance README with module details and features
    Expanded specifications and added details about supported magnetic switches and features.
2026-03-09 Update README formatting and section titles
2026-03-12 Change the 3D model data path settings.
2026-03-25 Add photos to README
    Added three new photos to the README.
2026-03-25 Fix formatting in README for buying options
2026-03-25 Update multiplexer model in README
2026-03-25 Update purchase link for MagneticSwitch & POT Module
2026-03-25 Improve README formatting and add channel mapping
    Enhanced the README with formatting and added channel mapping for the analog multiplexer.
